# Keil uVision project nucleo-h743zi.uvprojx, settings and files
target arm-nucleo-h743zi (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: blinky_button
  AfterMake: fromelf --bin --output .\build_nucleo-h743zi\blinky_button.bin .\build_nucleo-h743zi\blinky_button.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H743xx
  c include: .;..\..\..\..\include;..\..\..\ports\arm-cm;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\nucleo-h743zi
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: blinky_button.hpp blinky1.cpp blinky3.cpp bsp.hpp bsp_nucleo-h743zi.cpp button2a.cpp button2b.cpp main.cpp
  group nucleo-h743zi
    ../../../../3rd_party/nucleo-h743zi/arm/: startup_stm32h743xx.s
    ../../../../3rd_party/nucleo-h743zi/: stm32h743xx.h system_stm32h7xx.c
  group sst
    ../../../src/: sst.cpp
  group sst_port
    ../../../ports/arm-cm/: sst_port.cpp sst_port.hpp
