# Keil uVision project ek-tm4c123gxl.uvprojx, settings and files
target ek-tm4c123gxl (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky_button
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT
  c misc: -Wno-c11-extensions -Wno-padded
  c include: ..;..\..\..\..\include;..\..\..\ports\arm-cm;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: blinky1.cpp blinky3.cpp bsp_ek-tm4c123gxl.cpp button2a.cpp button2b.cpp main.cpp blinky_button.hpp bsp.hpp
  group ek-tm4c123gxl
    ../../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
    ../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
  group sst
    ../../../src/: sst.cpp
  group sst_port
    ../../../ports/arm-cm/: sst_port.cpp sst_port.hpp
