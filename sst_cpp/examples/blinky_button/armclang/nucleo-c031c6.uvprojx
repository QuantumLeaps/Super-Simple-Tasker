# Keil uVision project nucleo-c031c6.uvprojx, settings and files
target nucleo-c031c6 (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blinky_button
  AfterMake: fromelf --bin --output .\build_nucleo-c031c6\blinky_button.bin .\build_nucleo-c031c6\blinky_button.axf
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: .;..\..\..\..\include;..\..\..\ports\arm-cm;..\..\..\..\3rd_party\nucleo-c031c6
  asm define: Stack_Size=2048 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --entry Reset_Handler
  group Application
    ../: blinky_button.hpp blinky1.cpp blinky3.cpp bsp.hpp bsp_nucleo-c031c6.cpp button2a.cpp button2b.cpp main.cpp
  group nucleo-c031c6
    ../../../../3rd_party/nucleo-c031c6/: stm32c031xx.h system_stm32c0xx.c
    ../../../../3rd_party/nucleo-c031c6/arm/: startup_stm32c031xx.s
  group sst
    ../../../src/: sst.cpp
  group sst_port
    ../../../ports/arm-cm/: sst_port.cpp sst_port.hpp
