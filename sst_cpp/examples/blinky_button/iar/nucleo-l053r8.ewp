# IAR project nucleo-l053r8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\include; ..\..\..\ports\arm-cm; ..\..\..\..\3rd_party\nucleo-l053r8
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky_button.bin
  ILINK.IlinkOutputFile: blinky_button.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: blinky1.cpp blinky3.cpp blinky_button.hpp bsp.hpp bsp_nucleo-l053r8.cpp button2a.cpp button2b.cpp main.cpp
  group nucleo-l053r8
    ../../../../3rd_party/nucleo-l053r8/iar/: startup_stm32l053xx.s
    ../../../../3rd_party/nucleo-l053r8/: stm32l053xx.h system_stm32l0xx.c
  group sst
    ../../../src/: sst.cpp
  group sst_port
    ../../../ports/arm-cm/: sst_port.cpp sst_port.hpp
