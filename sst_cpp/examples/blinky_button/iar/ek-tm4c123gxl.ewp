# IAR project ek-tm4c123gxl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\include; ..\..\..\ports\arm-cm; ..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\3rd_party\ek-tm4c123gxl
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky_button.bin
  ILINK.IlinkOutputFile: blinky_button.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: blinky1.cpp blinky3.cpp bsp.hpp bsp_ek-tm4c123gxl.cpp button2a.cpp button2b.cpp main.cpp
  group ek-tm4c123gxl
    ../../../../3rd_party/ek-tm4c123gxl/iar/: startup_TM4C123GH6PM.s
    ../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
  group sst
    ../../../src/: sst.cpp
  group sst_port
    ../../../ports/arm-cm/: sst_port.cpp sst_port.hpp
