# IAR project nucleo-c031c6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32C031C6 ST STM32C031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32C031xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\include; ..\..\..\ports\arm-cm; ..\..\..\..\3rd_party\nucleo-c031c6
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky_button.bin
  ILINK.IlinkOutputFile: blinky_button.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: blinky1.cpp blinky3.cpp blinky_button.hpp bsp.hpp bsp_nucleo-c031c6.cpp button2a.cpp button2b.cpp main.cpp
  group nucleo-c031c6
    ../../../../3rd_party/nucleo-c031c6/iar/: startup_stm32c031xx.s
    ../../../../3rd_party/nucleo-c031c6/: stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h
  group sst
    ../../../src/: sst.cpp
  group sst_port
    ../../../ports/arm-cm/: sst_port.cpp sst_port.hpp
