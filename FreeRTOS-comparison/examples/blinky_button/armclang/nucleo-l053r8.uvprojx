# Keil uVision project nucleo-l053r8.uvprojx, settings and files
target nucleo-l053r8 (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blinky_button
  AfterMake: fromelf --bin --output .\build_nucleo-l053r8\blinky_button.bin .\build_nucleo-l053r8\blinky_button.axf
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c misc: -Wno-padded
  c include: ..;..\..\..\include;..\..\..\portable\GCC\ARM_CM0;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Application
    ../: FreeRTOSConfig.h blinky_button.h bsp.h main.c bsp_nucleo-l053r8.c blinky1.c blinky3.c button2a.c button2b.c
  group nucleo-l053r8
    ../../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
    ../../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c
  group FreeRTOS-Kernel
    ../../../: list.c queue.c tasks.c
    ../../../portable/GCC/ARM_CM0/: port.c
