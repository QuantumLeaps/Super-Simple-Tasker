# IAR project nucleo-h743zi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\include; ..\..\..\ports\arm-cm; ..\..\..\..\3rd_party\nucleo-h743zi
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky_button.bin
  ILINK.IlinkOutputFile: blinky_button.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: blinky1.c blinky3.c blinky_button.h bsp.h bsp_nucleo-h743zi.c button2a.c button2b.c main.c
  group nucleo-h743zi
    ../../../../3rd_party/nucleo-h743zi/iar/: startup_stm32h743xx.s
    ../../../../3rd_party/nucleo-h743zi/: stm32h743xx.h system_stm32h7xx.c
  group sst
    ../../../src/: sst.c
  group sst_port
    ../../../ports/arm-cm/: sst_port.c sst_port.h
