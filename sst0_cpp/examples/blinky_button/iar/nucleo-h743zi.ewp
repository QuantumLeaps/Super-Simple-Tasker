# IAR project nucleo-h743zi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\include; ..\..\..\ports\arm-cm; ..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\3rd_party\nucleo-h743zi
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky_button.bin
  ILINK.IlinkOutputFile: blinky_button.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: blinky1.cpp blinky3.cpp blinky_button.hpp bsp.hpp bsp_nucleo-h743zi.cpp button2a.cpp button2b.cpp main.cpp
  group nucleo-h743zi
    ../../../../3rd_party/nucleo-h743zi/iar/: startup_stm32h743xx.s
    ../../../../3rd_party/nucleo-h743zi/: stm32h743xx.h system_stm32h7xx.c
  group sst
    ../../../src/: sst0.cpp
  group sst_port
    ../../../ports/arm-cm/: sst_port.hpp
