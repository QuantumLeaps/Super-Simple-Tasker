# IAR project iar_nucleo-l053r8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\src; ..\..\ports\arm-cm; ..\..\targets\nucleo-l053r8
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: iar_nucleo-l053r8.bin
  ILINK.IlinkOutputFile: iar_nucleo-l053r8.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: blinky1.c blinky3.c blinky_button.h bsp.h bsp_nucleo-l053r8.c button2a.c button2b.c main.c
  group nucleo-l053r8
    ../../targets/nucleo-l053r8/iar/: startup_stm32l053xx.s
    ../../targets/nucleo-l053r8/: stm32l053xx.h system_stm32l0xx.c
  group SST
    ../../src/: qassert.h sst.c sst.h
  group SST_PORT
    ../../ports/arm-cm/: sst_port.c sst_port.h
