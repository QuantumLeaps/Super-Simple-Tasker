# Keil uVision project arm_nucleo-h743zi.uvprojx, settings and files
target arm-nucleo-h743zi (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: blinky-button
  AfterMake: fromelf --bin --output .\arm_nucleo-h743zi\blinky-button.bin .\arm_nucleo-h743zi\blinky-button.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H743xx
  c include: .;..\..\include;..\..\ports\arm-cm;..\..\targets\nucleo-h743zi
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --entry Reset_Handler
  group Applicatioin
    ./: blinky_button.h blinky1.c blinky3.c bsp.h bsp_nucleo-h743zi.c button2a.c button2b.c main.c
  group nucleo-h743zi
    ../../targets/nucleo-h743zi/arm/: startup_stm32h743xx.s
    ../../targets/nucleo-h743zi/: system_stm32h7xx.c
  group SST
    ../../src/: sst.c
  group SST_PORT
    ../../ports/arm-cm/: sst_port.c sst_port.h
