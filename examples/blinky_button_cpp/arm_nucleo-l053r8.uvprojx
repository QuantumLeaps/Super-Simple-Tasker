# Keil uVision project arm_nucleo-l053r8.uvprojx, settings and files
target arm_nucleo-l053r8 (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blinky-button
  AfterMake: fromelf --bin --output .\arm_nucleo-l053r8\blinky-button.bin .\arm_nucleo-l053r8\blinky-button.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c misc: -Wno-padded
  c include: .;..\..\src_cpp;..\..\ports_cpp\arm-cm;..\..\targets\nucleo-l053r8
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Application
    ./: blinky_button.hpp blinky1.cpp blinky3.cpp bsp.hpp bsp_nucleo-l053r8.cpp button2a.cpp button2b.cpp main.cpp
  group nucleo-l053r8
    ../../targets/nucleo-l053r8/arm/: startup_stm32l053xx.s
    ../../targets/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
  group sst_cpp
    ../../src_cpp/: sst.cpp qassert.h sst.hpp
  group sst_port_cpp
    ../../ports_cpp/arm-cm/: sst_port.cpp sst_port.hpp
